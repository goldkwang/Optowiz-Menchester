<?xml version="1.0" encoding="iso-8859-1"?>

<project>
  <fileVersion>1</fileVersion>
  <configuration>
    <name>Debug</name>
    <toolchain>
      <name>MAXQ</name>
    </toolchain>
    <debug>1</debug>
    <settings>
      <name>C-SPY</name>
      <archiveVersion>1</archiveVersion>
      <data>
        <version>1</version>
        <wantNonLocal>1</wantNonLocal>
        <debug>1</debug>
        <option>
          <name>CInput</name>
          <state>1</state>
        </option>
        <option>
          <name>MacUseFile</name>
          <state>0</state>
        </option>
        <option>
          <name>MacFile</name>
          <state></state>
        </option>
        <option>
          <name>DynDriver</name>
          <state>MAXQOWL</state>
        </option>
        <option>
          <name>RunToEnable</name>
          <state>1</state>
        </option>
        <option>
          <name>RunToName</name>
          <state>main</state>
        </option>
        <option>
          <name>OCGenSlave</name>
          <state>1</state>
        </option>
        <option>
          <name>DdfFileSlave</name>
          <state>1</state>
        </option>
        <option>
          <name>DdfOverride</name>
          <state>0</state>
        </option>
        <option>
          <name>DdfFileName</name>
          <state>$TOOLKIT_DIR$\config\DS4835.ddf</state>
        </option>
        <option>
          <name>CExtraOptionsCheck</name>
          <state>0</state>
        </option>
        <option>
          <name>CExtraOptions</name>
          <state></state>
        </option>
      </data>
    </settings>
    <settings>
      <name>MAXQJTAG</name>
      <archiveVersion>1</archiveVersion>
      <data>
        <version>1</version>
        <wantNonLocal>1</wantNonLocal>
        <debug>1</debug>
        <option>
          <name>JTAGDriverDummy</name>
          <state>1</state>
        </option>
        <option>
          <name>OJtagExtraOptions</name>
          <state></state>
        </option>
        <option>
          <name>JtagComPort</name>
          <state>com1</state>
        </option>
        <option>
          <name>EnableDataFlashOffset</name>
          <state>0</state>
        </option>
        <option>
          <name>EnableDebugLog</name>
          <state>0</state>
        </option>
        <option>
          <name>EnableEraseTimeDlay</name>
          <state>0</state>
        </option>
        <option>
          <name>EnableJtagClock</name>
          <state>0</state>
        </option>
        <option>
          <name>EnableMasterErase</name>
          <state>0</state>
        </option>
        <option>
          <name>EnableMaxStart</name>
          <state>0</state>
        </option>
        <option>
          <name>EnablePostErase</name>
          <state>0</state>
        </option>
        <option>
          <name>EnablePostLoad</name>
          <state>0</state>
        </option>
        <option>
          <name>EnablePostLoadDlay</name>
          <state>0</state>
        </option>
        <option>
          <name>EnableRamPassword</name>
          <state>0</state>
        </option>
        <option>
          <name>EnablePreErase</name>
          <state>0</state>
        </option>
        <option>
          <name>JtagClock</name>
          <state></state>
        </option>
        <option>
          <name>JtagPostErase</name>
          <state></state>
        </option>
        <option>
          <name>JtagPostLoad</name>
          <state></state>
        </option>
        <option>
          <name>JtagRamPassword</name>
          <state></state>
        </option>
        <option>
          <name>JtagMaxStart</name>
          <state>6000</state>
        </option>
        <option>
          <name>JtagEraseTimeDlay</name>
          <state>500</state>
        </option>
        <option>
          <name>JtagPostLoadDlay</name>
          <state>0</state>
        </option>
        <option>
          <name>JtagMasterErase</name>
          <state></state>
        </option>
        <option>
          <name>JtagDataFlashOffset</name>
          <state></state>
        </option>
        <option>
          <name>JtagDebugLog</name>
          <state></state>
        </option>
        <option>
          <name>JtagEnableContext</name>
          <state>1</state>
        </option>
        <option>
          <name>JtagPreEraseSel</name>
          <version>0</version>
          <state>0</state>
        </option>
        <option>
          <name>JtagPreEraseExtraOption</name>
          <state></state>
        </option>
      </data>
    </settings>
    <settings>
      <name>MAXQOWL</name>
      <archiveVersion>1</archiveVersion>
      <data>
        <version>0</version>
        <wantNonLocal>1</wantNonLocal>
        <debug>1</debug>
        <option>
          <name>OWLDriverDummy</name>
          <state>1</state>
        </option>
        <option>
          <name>OWLExtraOptions</name>
          <state></state>
        </option>
        <option>
          <name>OWLComPort</name>
          <state>com15</state>
        </option>
        <option>
          <name>EnableDataFlashOffset</name>
          <state>0</state>
        </option>
        <option>
          <name>EnableDebugLog</name>
          <state>0</state>
        </option>
        <option>
          <name>EnableEraseTimeDlay</name>
          <state>0</state>
        </option>
        <option>
          <name>EnableHyperdrive</name>
          <state>0</state>
        </option>
        <option>
          <name>EnableMasterErase</name>
          <state>0</state>
        </option>
        <option>
          <name>EnableMaxStart</name>
          <state>0</state>
        </option>
        <option>
          <name>EnablePostErase</name>
          <state>0</state>
        </option>
        <option>
          <name>EnablePostLoad</name>
          <state>0</state>
        </option>
        <option>
          <name>EnablePostLoadDlay</name>
          <state>0</state>
        </option>
        <option>
          <name>EnableRamPassword</name>
          <state>0</state>
        </option>
        <option>
          <name>EnablePreErase</name>
          <state>0</state>
        </option>
        <option>
          <name>OWLPostErase</name>
          <state></state>
        </option>
        <option>
          <name>OWLPostLoad</name>
          <state></state>
        </option>
        <option>
          <name>OWLRamPassword</name>
          <state></state>
        </option>
        <option>
          <name>OWLMaxStart</name>
          <state>6000</state>
        </option>
        <option>
          <name>OWLEraseTimeDlay</name>
          <state>500</state>
        </option>
        <option>
          <name>OWLPostLoadDlay</name>
          <state>0</state>
        </option>
        <option>
          <name>OWLMasterErase</name>
          <state></state>
        </option>
        <option>
          <name>OWLDataFlashOffset</name>
          <state></state>
        </option>
        <option>
          <name>OWLDebugLog</name>
          <state></state>
        </option>
        <option>
          <name>OWLEnableContext</name>
          <state>0</state>
        </option>
        <option>
          <name>OWLPreEraseSel</name>
          <version>0</version>
          <state>0</state>
        </option>
        <option>
          <name>OWLPreEraseExtraOption</name>
          <state></state>
        </option>
      </data>
    </settings>
    <settings>
      <name>MAXQSIM</name>
      <archiveVersion>1</archiveVersion>
      <data>
        <version>2</version>
        <wantNonLocal>1</wantNonLocal>
        <debug>1</debug>
        <option>
          <name>SIMDriverDummy</name>
          <state>1</state>
        </option>
        <option>
          <name>OCEnableRegBp</name>
          <state>0</state>
        </option>
        <option>
          <name>RomFileSlave</name>
          <state>1</state>
        </option>
        <option>
          <name>RomFileName</name>
          <state>$TOOLKIT_DIR$\config\DS4835.hex</state>
        </option>
        <option>
          <name>RomOverride</name>
          <state>0</state>
        </option>
        <option>
          <name>OCHardwareMul</name>
          <state>1</state>
        </option>
      </data>
    </settings>
    <debuggerPlugins>
      <plugin>
        <file>$EW_DIR$\common\plugins\CodeCoverage\CodeCoverage.ewplugin</file>
        <loadFlag>1</loadFlag>
      </plugin>
      <plugin>
        <file>$EW_DIR$\common\plugins\Orti\Orti.ewplugin</file>
        <loadFlag>0</loadFlag>
      </plugin>
      <plugin>
        <file>$EW_DIR$\common\plugins\Profiling\Profiling.ewplugin</file>
        <loadFlag>1</loadFlag>
      </plugin>
      <plugin>
        <file>$EW_DIR$\common\plugins\Stack\Stack.ewplugin</file>
        <loadFlag>1</loadFlag>
      </plugin>
    </debuggerPlugins>
  </configuration>
  <configuration>
    <name>Release</name>
    <toolchain>
      <name>MAXQ</name>
    </toolchain>
    <debug>0</debug>
    <settings>
      <name>C-SPY</name>
      <archiveVersion>1</archiveVersion>
      <data>
        <version>1</version>
        <wantNonLocal>1</wantNonLocal>
        <debug>0</debug>
        <option>
          <name>CInput</name>
          <state>1</state>
        </option>
        <option>
          <name>MacUseFile</name>
          <state>0</state>
        </option>
        <option>
          <name>MacFile</name>
          <state></state>
        </option>
        <option>
          <name>DynDriver</name>
          <state>MAXQSIM</state>
        </option>
        <option>
          <name>RunToEnable</name>
          <state>1</state>
        </option>
        <option>
          <name>RunToName</name>
          <state>main</state>
        </option>
        <option>
          <name>OCGenSlave</name>
          <state>1</state>
        </option>
        <option>
          <name>DdfFileSlave</name>
          <state>1</state>
        </option>
        <option>
          <name>DdfOverride</name>
          <state>0</state>
        </option>
        <option>
          <name>DdfFileName</name>
          <state></state>
        </option>
        <option>
          <name>CExtraOptionsCheck</name>
          <state>0</state>
        </option>
        <option>
          <name>CExtraOptions</name>
          <state></state>
        </option>
      </data>
    </settings>
    <settings>
      <name>MAXQJTAG</name>
      <archiveVersion>1</archiveVersion>
      <data>
        <version>1</version>
        <wantNonLocal>1</wantNonLocal>
        <debug>0</debug>
        <option>
          <name>JTAGDriverDummy</name>
          <state>1</state>
        </option>
        <option>
          <name>OJtagExtraOptions</name>
          <state></state>
        </option>
        <option>
          <name>JtagComPort</name>
          <state>com1</state>
        </option>
        <option>
          <name>EnableDataFlashOffset</name>
          <state>0</state>
        </option>
        <option>
          <name>EnableDebugLog</name>
          <state>0</state>
        </option>
        <option>
          <name>EnableEraseTimeDlay</name>
          <state>0</state>
        </option>
        <option>
          <name>EnableJtagClock</name>
          <state>0</state>
        </option>
        <option>
          <name>EnableMasterErase</name>
          <state>0</state>
        </option>
        <option>
          <name>EnableMaxStart</name>
          <state>0</state>
        </option>
        <option>
          <name>EnablePostErase</name>
          <state>0</state>
        </option>
        <option>
          <name>EnablePostLoad</name>
          <state>0</state>
        </option>
        <option>
          <name>EnablePostLoadDlay</name>
          <state>0</state>
        </option>
        <option>
          <name>EnableRamPassword</name>
          <state>0</state>
        </option>
        <option>
          <name>EnablePreErase</name>
          <state>0</state>
        </option>
        <option>
          <name>JtagClock</name>
          <state>200</state>
        </option>
        <option>
          <name>JtagPostErase</name>
          <state></state>
        </option>
        <option>
          <name>JtagPostLoad</name>
          <state></state>
        </option>
        <option>
          <name>JtagRamPassword</name>
          <state></state>
        </option>
        <option>
          <name>JtagMaxStart</name>
          <state>6000</state>
        </option>
        <option>
          <name>JtagEraseTimeDlay</name>
          <state>500</state>
        </option>
        <option>
          <name>JtagPostLoadDlay</name>
          <state>0</state>
        </option>
        <option>
          <name>JtagMasterErase</name>
          <state></state>
        </option>
        <option>
          <name>JtagDataFlashOffset</name>
          <state></state>
        </option>
        <option>
          <name>JtagDebugLog</name>
          <state></state>
        </option>
        <option>
          <name>JtagEnableContext</name>
          <state>1</state>
        </option>
        <option>
          <name>JtagPreEraseSel</name>
          <version>0</version>
          <state>0</state>
        </option>
        <option>
          <name>JtagPreEraseExtraOption</name>
          <state></state>
        </option>
      </data>
    </settings>
    <settings>
      <name>MAXQOWL</name>
      <archiveVersion>1</archiveVersion>
      <data>
        <version>0</version>
        <wantNonLocal>1</wantNonLocal>
        <debug>0</debug>
        <option>
          <name>OWLDriverDummy</name>
          <state>1</state>
        </option>
        <option>
          <name>OWLExtraOptions</name>
          <state></state>
        </option>
        <option>
          <name>OWLComPort</name>
          <state>com1</state>
        </option>
        <option>
          <name>EnableDataFlashOffset</name>
          <state>0</state>
        </option>
        <option>
          <name>EnableDebugLog</name>
          <state>0</state>
        </option>
        <option>
          <name>EnableEraseTimeDlay</name>
          <state>0</state>
        </option>
        <option>
          <name>EnableHyperdrive</name>
          <state>0</state>
        </option>
        <option>
          <name>EnableMasterErase</name>
          <state>0</state>
        </option>
        <option>
          <name>EnableMaxStart</name>
          <state>0</state>
        </option>
        <option>
          <name>EnablePostErase</name>
          <state>0</state>
        </option>
        <option>
          <name>EnablePostLoad</name>
          <state>0</state>
        </option>
        <option>
          <name>EnablePostLoadDlay</name>
          <state>0</state>
        </option>
        <option>
          <name>EnableRamPassword</name>
          <state>0</state>
        </option>
        <option>
          <name>EnablePreErase</name>
          <state>0</state>
        </option>
        <option>
          <name>OWLPostErase</name>
          <state></state>
        </option>
        <option>
          <name>OWLPostLoad</name>
          <state></state>
        </option>
        <option>
          <name>OWLRamPassword</name>
          <state></state>
        </option>
        <option>
          <name>OWLMaxStart</name>
          <state>6000</state>
        </option>
        <option>
          <name>OWLEraseTimeDlay</name>
          <state>500</state>
        </option>
        <option>
          <name>OWLPostLoadDlay</name>
          <state>0</state>
        </option>
        <option>
          <name>OWLMasterErase</name>
          <state></state>
        </option>
        <option>
          <name>OWLDataFlashOffset</name>
          <state></state>
        </option>
        <option>
          <name>OWLDebugLog</name>
          <state></state>
        </option>
        <option>
          <name>OWLEnableContext</name>
          <state>1</state>
        </option>
        <option>
          <name>OWLPreEraseSel</name>
          <version>0</version>
          <state>0</state>
        </option>
        <option>
          <name>OWLPreEraseExtraOption</name>
          <state></state>
        </option>
      </data>
    </settings>
    <settings>
      <name>MAXQSIM</name>
      <archiveVersion>1</archiveVersion>
      <data>
        <version>2</version>
        <wantNonLocal>1</wantNonLocal>
        <debug>0</debug>
        <option>
          <name>SIMDriverDummy</name>
          <state>1</state>
        </option>
        <option>
          <name>OCEnableRegBp</name>
          <state>0</state>
        </option>
        <option>
          <name>RomFileSlave</name>
          <state>1</state>
        </option>
        <option>
          <name>RomFileName</name>
          <state></state>
        </option>
        <option>
          <name>RomOverride</name>
          <state>0</state>
        </option>
        <option>
          <name>OCHardwareMul</name>
          <state>1</state>
        </option>
      </data>
    </settings>
    <debuggerPlugins>
      <plugin>
        <file>$EW_DIR$\common\plugins\CodeCoverage\CodeCoverage.ewplugin</file>
        <loadFlag>1</loadFlag>
      </plugin>
      <plugin>
        <file>$EW_DIR$\common\plugins\Orti\Orti.ewplugin</file>
        <loadFlag>0</loadFlag>
      </plugin>
      <plugin>
        <file>$EW_DIR$\common\plugins\Profiling\Profiling.ewplugin</file>
        <loadFlag>1</loadFlag>
      </plugin>
      <plugin>
        <file>$EW_DIR$\common\plugins\Stack\Stack.ewplugin</file>
        <loadFlag>1</loadFlag>
      </plugin>
    </debuggerPlugins>
  </configuration>
</project>


