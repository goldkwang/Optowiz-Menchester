<?xml version="1.0" encoding="iso-8859-1"?>

<workspace>
  <project>
    <path>$WS_DIR$\HSFP_10G_ER_V1_DML_APD.ewp</path>
  </project>
  <batchBuild/>
</workspace>


