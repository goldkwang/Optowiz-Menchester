# IAR project HSFP_10G_ER_V1_DML_APD.ewp, settings and files
configuration Debug (MAXQ, debug)
  General.OGChipSelectMenu: DS4835 DS4835
  General.GHeapSize: 100
  General.GStackSize: 50
  ICCMAXQ.CCIncludePath2: Source; Source\Drivers\; Source\LaserDriver\; Source\Customized\; Source\Application\; Source\MSA\
  ICCMAXQ.CCStdIncludePath: $TOOLKIT_DIR$\INC\; $TOOLKIT_DIR$\INC\CLIB\
  AMAXQ.AUserIncludes: Source; Source\Drivers\; Source\LaserDriver\; Source\MSA\; Source\Customized\; Source\Application\
  XLINK.XclFile: Source\Customized\lnkds4835.xcl
  XLINK.XlinkStackSize: 1
configuration Release (MAXQ)
  as the first configuration, except:
  General.OGChipSelectMenu: maxq200x MAXQ200x
  ICCMAXQ.CCDefines: NDEBUG
  group (top)
    source/: includes.h main.c
  group APP
    source/Application/: board.c board.h ddm.c ddm.h i2c_master_gpio.c i2c_master_gpio.h initialization.c initialization.h mcu_convert.c memory.h memory_access.c memory_access.h memory_map.h MemoryAccess.h module_config.h monitor.c monitor.h rosa_control.h state_transition.c state_transition.h tosa_control.c
  group Customized
    source/Customized/: i2cs_asm.asm i2cslave.c i2cslave.h isr.s66 lnkds4835.xcl lowinit.c
  group Drivers
    source/Drivers/: adc.c adc.h dc_dc.c dc_dc.h ds_dac.c ds_dac.h flash.c flash.h flash_asm.asm hwmul.s66 i2cm.c i2cm.h pwm.c pwm.h Q20_floatMACLIB_ieee754.asm tec.c tec.h timer.c timer.h twm.c twm.h
  group MSA
    source/MSA/: alarm_warning.c alarm_warning.h
